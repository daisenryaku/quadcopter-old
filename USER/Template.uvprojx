# Keil uVision project Template.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F411xxx,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE;..\HARDWARE\eMPL;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c item.c
  group CORE
    ../CORE/: startup_stm32f411xe.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/: led.c pwm.c I2C.c MPU6050.c niming.c pid.c Attitude.c
    ../HARDWARE/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group UCOS-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOS-PORT
    ../UCOSII/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group UCOS-CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
